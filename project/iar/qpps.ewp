# IAR project qpps.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: QN9020 NXP QN9020
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_CC
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\src\fw; ..\..\src\profiles; ..\..\src\profiles\qpp; ..\..\src\profiles\qpp\qpps; ..\..\src\profiles\ota\otas; ..\..\src\profiles\dis\diss; ..\..\src\app; ..\..\src\app\gap; ..\..\src\app\gatt; ..\..\src\app\smp; ..\..\src\app\qpps; ..\..\src\app\diss; ..\..\src\cmsis; ..\..\src\driver; ..\..\src\lib; ..\..\src\qnevb; ..\..\src\app\otas; ..\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: qpps.bin
  ILINK.IlinkOutputFile: qpps.out
  ILINK.IlinkIcfFile: ..\..\src\link\iar\qn9020_link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group app
    ../../src/app/diss/: app_diss.c app_diss_task.c
    ../../src/app/: app_env.c app_printf.c app_sys.c app_task.c app_util.c
    ../../src/app/gap/: app_gap.c app_gap_task.c
    ../../src/app/gatt/: app_gatt.c app_gatt_task.c
    ../../src/app/otas/: app_otas_task.c
    ../../src/app/qpps/: app_qpps.c app_qpps_task.c
    ../../src/app/smp/: app_smp.c app_smp_task.c
  group drivers
    ../../src/driver/: gpio.c rtc.c serialflash.c sleep.c syscon.c timer.c uart.c wdt.c
  group lib
    ../../src/lib/iar/: qn9020b2_lib_peripheral.a
    ../../src/profiles/ota/otas/: qn_ota_b2.a
  group main
    ../../src/main/: app_main.c
  group profiles
    ../../src/profiles/dis/diss/: diss.c diss_task.c
    ../../src/profiles/: prf_utils.c
    ../../src/profiles/qpp/qpps/: qpps.c qpps_task.c
  group qnevb
    ../../src/qnevb/: button.c led.c
  group retarget
    ../../src/retarget/: retarget.c
  group startup
    ../../src/startup/iar/: startup.s
  group usr
    ../src/: system.c usr_design.c
